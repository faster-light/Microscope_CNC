#include "stdafx.h"
#include <Windows.h>
#include <iostream>
#include <string>

#include <dos.h>
#include <stdio.h>

using namespace std;

HANDLE hSerial;

void initialization()
{
	LPCTSTR sPortName = L"COM3";  //пробуем открывать порт 

	hSerial = ::CreateFile(sPortName, GENERIC_READ | GENERIC_WRITE, 0, 0, OPEN_EXISTING, FILE_ATTRIBUTE_NORMAL, 0);   //файл записи
	if (hSerial == INVALID_HANDLE_VALUE)
	{
		if (GetLastError() == ERROR_FILE_NOT_FOUND)		//если ошибки при подключении порта
		{
			cout << "serial port does not exist.\n";
		}
		cout << "some other error occurred.\n";
	}


	DCB dcbSerialParams = { 0 };
	dcbSerialParams.DCBlength = sizeof(dcbSerialParams);
	if (!GetCommState(hSerial, &dcbSerialParams))
	{
		cout << "getting state error\n";
	}
	dcbSerialParams.BaudRate = CBR_9600;
	dcbSerialParams.ByteSize = 8;
	dcbSerialParams.StopBits = ONESTOPBIT;
	dcbSerialParams.Parity = NOPARITY;
	if (!SetCommState(hSerial, &dcbSerialParams))
	{
		cout << "error setting serial port state\n";
	}
}

int sent(int a)				//функция отправки данных
{

	int a1 = a / 100000;		//перевод в символьный формат для отправки (чет пока недопетрил как его легче сделать)
	int a2 = a / 10000 - a1 * 10;
	int a3 = a / 1000 - a1 * 100 - a2 * 10;
	int a4 = a / 100 - a1 * 1000 - a2 * 100 - a3 * 10;
	int a5 = a / 10 - a1 * 10000 - a2 * 1000 - a3 * 100 - a4 * 10;
	int a6 = a - a1 * 100000 - a2 * 10000 - a3 * 1000 - a4 * 100 - a5 * 10;


	char data[6];		// 6 байт для отправки

	data[0] = a1 + '0';		//переводим в символы
	data[1] = a2 + '0';
	data[2] = a3 + '0';
	data[3] = a4 + '0';
	data[4] = a5 + '0';
	data[5] = a6 + '0';

	//		cout << data << endl;

	DWORD dwSize = sizeof(data);		// отправка
	DWORD dwBytesWritten;
	LPOVERLAPPED ov;

	BOOL iRet = WriteFile(hSerial, data, dwSize, &dwBytesWritten, NULL);

	cout << dwSize << " Bytes in string. " << dwBytesWritten << " Bytes sended. " << endl;



		char result[2];		//принятие 2 байт данных о выполнии запроса

	int s = 0;
	DWORD iSize;
	char sReceivedChar;
	while (s <= 1)
	{

	ReadFile(hSerial, &sReceivedChar, 1, &iSize, 0);
	if (iSize > 0)
	{
	result[s] = sReceivedChar;
	s++;

	}
	}


	int b1 = result[0] - '0';		//первод в числа (кода ошибки)
	int b2 = result[1] - '0';

	int result_int = b1*10+b2;
	
	return 0;			//возвращение


}

int _tmain(int argc, _TCHAR* argv[])
{
	initialization();
	system("pause");
	int w = sent(110124);

	//	cout << w << endl;

	system("pause");
	return 0;
}